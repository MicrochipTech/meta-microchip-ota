EXTRA_OECONF:append = " --enable-lto"
