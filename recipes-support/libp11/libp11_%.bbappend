EXTRA_OECONF:append:${MACHINE} = " --with-pkcs11-module=/usr/lib/p11-kit-proxy.so"

