FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGES = " \
        file://Masters2024.png;outsuffix=default \
"
